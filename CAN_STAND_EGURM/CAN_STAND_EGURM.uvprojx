# Keil uVision project CAN_STAND_EGURM.uvprojx, settings and files
target GD32E503RET6 (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: CAN_STAND_EGURM
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: GD32E50X GD32E50X_HD
  c include: .\gd32e50x\cmsis\include;.\gd32e50x\standard_peripheral\Include;.\User\inc;.\USB_Device\class\Include;.\USB_Device\device\Include;.\USB_Device\usbd\Include;.\User\src;.\CAN\inc;.\Configure_Periph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/src/: gd32e50x_it.c main.c timers_10_and_100_us.c can_egurm.c can_dm.c can_sas_message.c test.c can_uds_response.c can_uds_request.c can_uds_service_send.c can_uds_request_service.c can_uds_response_service.c can_uds_negative_response.c uartcan_rx.c uartcan_tx.c
  group Conf_Periph
    ./Configure_Periph/src/: can_init_egurm.c timers_10_and_100_us_init.c uartcan_init.c
  group CMSIS
    ./gd32e50x/cmsis/source/: startup_gd32e50x_hd.s systick.c system_gd32e50x.c
  group StdPeriph
    ./gd32e50x/standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
software components: CMSIS:CORE 5.6.0
