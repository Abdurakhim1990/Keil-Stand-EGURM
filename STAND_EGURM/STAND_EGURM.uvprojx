# Keil uVision project STAND_EGURM.uvprojx, settings and files
target GD32E503RET6 (6190000::V6.19::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: STAND_EGURM
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: GD32E50X GD32E50X_HD
  c include: .\gd32e50x\cmsis\include;.\gd32e50x\standard_peripheral\Include;.\User\inc;.\USB_Device\class\Include;.\USB_Device\device\Include;.\USB_Device\usbd\Include;.\User\src;.\CAN\inc;.\Configure_Periph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/src/: gd32e50x_it.c main.c usbd_egurm.c adc_egurm.c timers_10_and_100_us.c usart_akip_1148a.c encoder_egurm.c mufta_egurm.c voltage_revers.c ingition.c servo_mr_j2s_a.c uartcan.c stand_control.c stand_error.c
  group Conf_Periph
    ./Configure_Periph/src/: adc_init_egurm.c custom_hid_itf.c gd32e50x_usbd_hw.c timers_10_and_100_us_init.c usart_akip_1148a_init.c encoder_init_egurm.c mufta_egurm_init.c servo_mr_j2s_a_init.c uartcan_init.c stand_control_init.c
  group CMSIS
    ./gd32e50x/cmsis/source/: startup_gd32e50x_hd.s systick.c system_gd32e50x.c
  group StdPeriph
    ./gd32e50x/standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group USBD_Class
    ./USB_Device/class/Source/: custom_hid_core.c
  group USBD_Device
    ./USB_Device/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Core
    ./USB_Device/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
software components: CMSIS:CORE 5.6.0
